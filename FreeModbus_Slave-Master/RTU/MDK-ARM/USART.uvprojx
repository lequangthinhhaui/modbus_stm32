# Keil uVision project USART.uvprojx, settings and files
target USART (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: TEMP
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F103xB,USE_HAL_DRIVER,USE_FULL_LL_HAL_DRIVER
  c include: ..\Drivers\CMSIS\Device\ST\STM32F1xx\Include;..\Drivers\CMSIS\Include;..\Drivers\STM32F1xx_HAL_Driver\Inc;..\Drivers\STM32F1xx_HAL_Driver\Inc\Legacy;..\Src;..\Inc;..\SYSTEM\sys;..\HARDWARE\EXTI;..\SYSTEM\usart;..\HARDWARE\FreeModbus\modbus\ascii;..\HARDWARE\FreeModbus\modbus\functions;..\HARDWARE\FreeModbus\modbus\include;..\HARDWARE\FreeModbus\modbus\rtu;..\HARDWARE\FreeModbus\port;..\HARDWARE\FreeModbus\port\no_os
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group CORE
    ../Drivers/CMSIS/Device/ST/STM32F1xx/Source/Templates/arm/: startup_stm32f103xg.s
  group HAL
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_cortex.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_pwr.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_dma.c stm32f1xx_hal_uart.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c
  group HARDWARE
    ../HARDWARE/EXTI/: exti.c
    ../Src/: bsp.c gpio.c irq_callback.c tim.c usart.c
  group SYSTEM
    ../SYSTEM/sys/: sys.c
  group RTU
    ../HARDWARE/FreeModbus/modbus/ascii/: mbascii.c
    ../HARDWARE/FreeModbus/modbus/functions/: mbfunccoils.c mbfunccoils_m.c mbfuncdiag.c mbfuncdisc.c mbfuncdisc_m.c mbfuncholding.c mbfuncholding_m.c mbfuncinput.c mbfuncinput_m.c mbfuncother.c mbutils.c
    ../HARDWARE/FreeModbus/modbus/rtu/: mbcrc.c mbrtu.c mbrtu_m.c
    ../HARDWARE/FreeModbus/modbus/: mb.c mb_m.c
    ../HARDWARE/FreeModbus/port/: user_mb_app.c user_mb_app_ex.c user_mb_app_m.c
    ../HARDWARE/FreeModbus/port/no_os/: port.c portevent.c portevent_m.c portserial.c portserial_m.c porttimer.c porttimer_m.c
  group USER
    ../Src/: main.c stm32f1xx_hal_msp.c stm32f1xx_it.c system_stm32f1xx.c
